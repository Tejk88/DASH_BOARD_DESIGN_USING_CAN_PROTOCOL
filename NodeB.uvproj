# Keil uVision project NodeB.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: NodeB +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s CAN2_Intrr.c delay.c CAN2_Driver.c LCD_4bit_driver.c mainB.c nodeB_practice_prog.c prac_mainB.c Timer_Intrr.c UART_Driver.c
