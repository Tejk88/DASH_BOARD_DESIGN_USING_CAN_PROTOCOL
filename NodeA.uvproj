# Keil uVision project NodeA.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: NodeA +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s Uart_Intr.c UART_Driver.c Timer_Intr.c mainA.c main_A_Practice_codes.c LCD_4bit_driver.c Driver_nodeA.c delay.c CAN2_Driver.c ADC_Driver.c header.h
